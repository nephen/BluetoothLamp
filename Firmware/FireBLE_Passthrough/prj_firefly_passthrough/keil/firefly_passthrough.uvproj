# Keil uVision project firefly_passthrough.uvproj, settings and files
target passthrough (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: QN9020 NXP
  cpu: IRAM(0x10008000-0x1000FFFF) IROM(0x10000000-0x10007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: firefly_passthrough
  AfterMake: fromelf --bin --output ./bin/firefly_passthrough.bin ./obj/firefly_passthrough.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CATCH_LOG
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qpps;..\..\src\profiles\dis\diss;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\qpps;..\..\src\app\diss;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\app\otas;..\..\src\profiles\ota\otas;..\src\fireble;..\src\fireble\app;..\src\fireble\profile;..\..\src\profiles\qpp;..\..\src\profiles\qpp\qpps
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c at_command.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
    ../../src/app/otas/: app_otas_task.c
    ../src/: app_com.c
    ../../src/app/diss/: app_diss.c app_diss_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/qpp/qpps/: qpps.c qpps_task.c
    ../../src/profiles/dis/diss/: diss.c diss_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c timer.c pwm.c i2c.c serialflash.c spi.c
    ../src/: usr_spi.c
  group lib
    ../../src/profiles/ota/otas/: qn_ota.lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
  group fireblue_evb
    ../../src/qnevb/: led.c
  group fireble
    ../src/fireble/app/: app_fireble.c app_fireble_task.c
    ../src/fireble/profile/: fireble.c fireble_task.c
  group retarget
    ../../src/retarget/: retarget.c
